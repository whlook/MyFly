# Keil uVision project PRJ.uvprojx, settings and files
target fly (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fly2017 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\PRJ;.\Apps;.\Drivers;.\Libs\inc;.\RTE;.\RTE\Device\STM32F407VE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group Drivers
    ./Drivers/: i2c_driver.c mpu9250_driver.c pwm_driver.c sdio_sd_driver.c time_driver.c usart_driver.c fash.c
  group Apps
    ./Apps/: init.c my_filter.c my_imu.c my_math.c my_protocol.c pid.c sd_data.c offset.c control.c to_pc.c sys_time.c duty.c
  group Libs
    ./Libs/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.3.1
